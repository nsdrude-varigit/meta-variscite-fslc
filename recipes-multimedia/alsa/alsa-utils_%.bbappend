PACKAGECONFIG_append = "bat"
